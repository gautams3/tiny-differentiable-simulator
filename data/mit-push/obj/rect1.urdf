Commit message: WIP set up push experiment

File: data/mit-push/obj/rect1.urdf (robot description, URDF)
Before this commit: robot push_object, 5 links, 4 joints
Links:
- link link_object: mass 10.0 -> 0.1
